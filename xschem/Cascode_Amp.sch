v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Micah Tseng"
}
C {devices/iopin.sym} 130 -170 0 0 {name=p1 lab=Vgg_1v8

}
C {devices/iopin.sym} 130 -140 0 0 {name=p1 lab=RF_out
}
C {devices/iopin.sym} 130 -110 0 0 {name=p1 lab=RF_in

}
C {devices/iopin.sym} 130 -80 0 0 {name=p1 lab=gnd

}
