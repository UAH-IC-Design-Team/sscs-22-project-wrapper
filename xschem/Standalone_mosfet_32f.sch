v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 140 -110 0 0 {name=p1 lab=signal_out
}
C {devices/title.sym} 160 30 0 0 {name=l1 author="Micah Tseng"
}
C {devices/iopin.sym} 140 -90 0 0 {name=p1 lab=signal_in
}
C {devices/iopin.sym} 140 -70 0 0 {name=p1 lab=gnd
}
