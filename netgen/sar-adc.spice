* NGSPICE file created from sar-adc.ext - technology: sky130A

* Top level circuit sar-adc

.end
